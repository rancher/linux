## drivers/misc/cxl/Kconfig
```kconfig
#
# IBM Coherent Accelerator (CXL) compatible devices
#

config CXL_BASE
	bool
	default n
```
